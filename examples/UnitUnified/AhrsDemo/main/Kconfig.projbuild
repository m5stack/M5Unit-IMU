## examples/UnitUnified/AhrsDemo/main/Kconfig.projbuild
```kconfig
# The "Target unit" choice is shared by all UnitUnified examples.
rsource "../../common/Kconfig.variant"
```
